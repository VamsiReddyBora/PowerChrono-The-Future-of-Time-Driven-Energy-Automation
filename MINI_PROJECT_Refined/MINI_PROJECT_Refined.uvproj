# Keil uVision project MINI_PROJECT_Refined.uvproj, settings and files
target MINIPROJECT_Refined (ARM-ADS)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: MINI_PROJECT_Refined +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group MAIN
    ./: main.c pin_connect_block.c pin_connect_block.h pin_function_defines.h defines.h Startup.s
  group LCD
    ./: lcd.c lcd_defines.h lcd_functions.h delay.h delay.c
  group KEYPAD
    ./: keymatrix.c
  group LED
    ./: led.c
  group RTC
    ./: rtc_functions.h rtc_defines.h rtc.c
  group INTERRUPT
    ./: eint.c eint_defines.h eint_functions.h
